# Keil uVision project ESP-AT-FreeRTOS-Library-M487.uvprojx, settings and files
target M487JIDAE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ESP-AT-FreeRTOS-Library-M487
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\Application\Inc;.\Application\Src;.\Library\Inc;.\Library\Src;..\M480_BSP\Library\StdDriver\inc;..\M480_BSP\Library\StdDriver\src;..\M480_BSP\ThirdParty\FreeRTOS\Source\include;..\M480_BSP\ThirdParty\FreeRTOS\Source\portable\MemMang;..\M480_BSP\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\M480_BSP\ThirdParty\FreeRTOS\Demo\Common\include;..\M480_BSP\ThirdParty\lwesp\lwesp\src;..\M480_BSP\ThirdParty\lwesp\lwesp\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application
    ./Application/Src/: main.c
    ./Application/Inc/: main.h FreeRTOSConfig.h
  group Library
    ./Library/Inc/: lwesp_opts.h lwesp_sys_port.h
  group StdLibrary
    ../M480_BSP/Library/StdDriver/src/: sys.c clk.c gpio.c uart.c pdma.c
  group ThirdParty/FreeRTOS
    ../M480_BSP/ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../M480_BSP/ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../M480_BSP/ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group ThirdParty/lwesp
    ../M480_BSP/ThirdParty/lwesp/lwesp/src/api/: lwesp_netconn.c
    ../M480_BSP/ThirdParty/lwesp/lwesp/src/lwesp/: lwesp_ap.c lwesp_buff.c lwesp.c lwesp_cli.c lwesp_conn.c lwesp_debug.c lwesp_dhcp.c lwesp_dns.c lwesp_evt.c lwesp_hostname.c lwesp_input.c lwesp_int.c lwesp_mdns.c lwesp_mem.c lwesp_parser.c lwesp_pbuf.c lwesp_ping.c lwesp_sntp.c lwesp_sta.c lwesp_threads.c lwesp_timeout.c lwesp_unicode.c lwesp_utils.c lwesp_wps.c
    ../M480_BSP/ThirdParty/lwesp/lwesp/src/system/: lwesp_ll_m480.c lwesp_sys_freertos.c
    ../M480_BSP/ThirdParty/lwesp/lwesp/src/cli/: cli.c
    ../M480_BSP/ThirdParty/lwesp/lwesp/src/apps/mqtt/: lwesp_mqtt_client.c lwesp_mqtt_client_api.c lwesp_mqtt_client_evt.c
    ../M480_BSP/ThirdParty/lwesp/lwesp/src/apps/http_server/: lwesp_http_server.c lwesp_http_server_fs.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.00.001
